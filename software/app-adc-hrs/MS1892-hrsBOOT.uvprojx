# Keil uVision project MS1892-hrsBOOT.uvprojx, settings and files
target MS1892HRS-useBOOT (ARM-ADS)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.3
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MS1892-App
  AfterMake: fromelf --bin --output .\obj\MS1892-App.bin .\obj\MS1892-App.axf
  c flags: Optim=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MM32F103xCxE_o\HAL_lib\inc;..\MM32F103xCxE_o\Include;..\Bsp\inc;..\Src\inc;..\Src\IWDG;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.3.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x7b000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ../MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
  group user
    ./: main.c uart.c
  group bsp
    ./: bsp.c led.c
    ../Bsp/: irq_rf.c spi.c
  group hal_lib
    ../MM32F103xCxE_o/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group ble_lib
    ../Src/lib/: mg_BLEpair_lib_m3.lib
  group ble_app
    ./: app.c
    ../bsp/: callback.c
  group IWDG
    ../Src/IWDG/: iwdg.c
  group ADC
    ../Src/ADC/: adc.c
