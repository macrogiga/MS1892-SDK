# Keil uVision project MS1892-OtaBoot.uvprojx, settings and files
target MS1892-OTABOOT (ARM-ADS)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.3
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MS1892-OTABOOT +hex
  c flags: OneElfS=1 wLevel=1
  c include: ..\MM32F103xCxE_o\HAL_lib\inc;..\MM32F103xCxE_o\Include;..\Bsp\inc;..\Src\inc;..\Src\IWDG;C:\Keil_v5\ARM\Pack\ARM\CMSIS\5.3.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./: main-boot.c
  group hal_lib
    ../MM32F103xCxE_o/HAL_lib/src/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group startup
    ../MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
