# Keil uVision project USB_BOOT.uvprojx, settings and files
target MS1892 (ARM-ADS)
  device: MM32F103CET MindMotion
  pack: MindMotion.MM32F103xCxE_DFP.1.0.3
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MS1892-USB_BOOT +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\MM32F103xCxE_o\HAL_lib\inc;..\MM32F103xCxE_o\Include;.\inc;..\MM32F103xCxE_o\USB_lib\inc;..\MM32F103xCxE_o\CMSIS\KEIL_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./src/: hw_config.c main.c scsi_data.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c mass_mal.c memory.c usb_bot.c mm32flash.c MM32x103_it.c
    ../MM32F103xCxE_o/HAL_lib/src/: HAL_pwr.c
  group USB_lib
    ../MM32F103xCxE_o/USB_lib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group HAL_lib
    ../MM32F103xCxE_o/HAL_lib/src/: HAL_gpio.c HAL_misc.c HAL_rcc.c HAL_uart.c HAL_flash.c
  group System
    ../MM32F103xCxE_o/Source/: system_MM32F103xCxE_o.c
    ../MM32F103xCxE_o/Source/KEIL_StartAsm/: startup_MM32F103xCxE_o.s
